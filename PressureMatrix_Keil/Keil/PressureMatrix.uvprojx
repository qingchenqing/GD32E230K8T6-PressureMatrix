# Keil uVision project PressureMatrix.uvprojx, settings and files
target GD32E230K8T6_PressureMatrix (6240000::V6.24::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(72000000) ELITTLE
  output: PressureMatrix +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\App;..\Vendor\CMSIS;..\Vendor\CMSIS\GD\GD32E23x\Include;..\Vendor\GD32E23x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../App/: main.c matrix.c serial.c systick.c interrupts.c matrix.h serial.h systick.h gd32e23x_libopt.h
  group CMSIS
    ../Vendor/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32 peripherals
    ../Vendor/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_gpio.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_usart.c
  group Startup
    ../Vendor/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Notes
    ../: README.md
